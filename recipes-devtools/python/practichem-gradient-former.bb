require protocolbridge.inc

SRCREV = "e5a444ea3896b9e0a20845e9861072e18201e8d1"
S = "${WORKDIR}/git/packages/practichem_gradient_former"

