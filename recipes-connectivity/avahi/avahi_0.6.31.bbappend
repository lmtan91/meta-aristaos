INITSCRIPT_NAME = "avahi-daemon"
INITSCRIPT_PARAMS = "start 99 2 3 4 5 . stop 20 0 1 6 ."
